{attribute 'qualified_only'}
VAR_GLOBAL
	
	// Inputs
	ATOM_AC_LINE AT %I* : UINT;

	// Outputs
	ATOM_SETPOINT AT %Q* : UINT;
	ATOM_RUN_ENABLE AT %Q* : UINT;

END_VAR
